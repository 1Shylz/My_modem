options:
  parameters:
    author: Crackvel
    generate_options: no_gui
    id: tx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq
  id: variable
  parameters:
    value: 400e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Crackvel\Desktop\gnuradio\nums
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: const
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '40'
    freq0: freq
    gain0: '40'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repeat_0, '0', osmosdr_sink_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_repeat_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_constellation_encoder_bc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
